# Keil uVision project TIMER.uvprojx, settings and files
target TIMER (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_ESP8266 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --locale=english
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\SYSTEM\usart3;..\SYSTEM\Gizwits;..\SYSTEM\Utils;..\SYSTEM\flash;..\SYSTEM\font;..\SYSTEM\lcd;..\HARDWARE\DHT11;..\SYSTEM\adc;..\HARDWARE\SERVO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/SERVO/: servo.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/usart3/: usart3.c
    ../SYSTEM/flash/: bsp_spi_flash.c
    ../SYSTEM/font/: fonts.c
    ../SYSTEM/lcd/: bsp_ili9341_lcd.c
    ../SYSTEM/adc/: bsp_adc.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_dbgmcu.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group Gizwits
    ../SYSTEM/Gizwits/: gizwits_product.c gizwits_protocol.c
  group Utils
    ../SYSTEM/Utils/: common.c dataPointTools.c ringbuffer.c
